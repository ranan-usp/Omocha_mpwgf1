* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__inv_4 I VDD VNW VSS ZN
XM1 ZN I VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=4
XM2 ZN I VDD VNW pfet_05v0 w=1.22u l=0.5u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__inv_4')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,5.6,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76,6.03,4.35)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34,5.02,1.16), (0.18,2.36,5.02,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,3.8),(1.12,3.8),(1.12,2.035),(1.84,2.035),(1.84,3.8),(2.34,3.8),(2.34,2.035),(2.86,2.035),(2.86,3.8),(3.36,3.8),(3.36,2.035),(4.08,2.035),(4.08,3.8),(4.58,3.8),(4.58,0.12),(3.98,0.12),(3.98,1.675),(3.46,1.675),(3.46,0.12),(2.86,0.12),(2.86,1.675),(2.34,1.675),(2.34,0.12),(1.74,0.12),(1.74,1.675),(1.22,1.675),(1.22,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,5.8,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,5.8,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.73, 1.745, 0.22, 0.22, 3, 1, 0.47, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 3.095, 1.745, 0.22, 0.22, 3, 1, 0.47, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(2.49,0.49,2.71,0.71), (0.25,0.69,0.47,0.91), (4.73,0.69,4.95,0.91), (1.37,0.735,1.59,0.955), (3.61,0.735,3.83,0.955), (1.37,2.63,1.59,2.85), (3.61,2.63,3.83,2.85), (0.25,2.68,0.47,2.9), (4.73,2.68,4.95,2.9), (1.37,3.1,1.59,3.32), (3.61,3.1,3.83,3.32), (0.25,3.15,0.47,3.37), (4.73,3.15,4.95,3.37), (2.49,3.19,2.71,3.41)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.37,1.74,1.95,2.15), (3.035,1.74,4.315,2.15)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(1.365,0.675),(1.365,1.44),(2.33,1.44),(2.33,2.39),(1.365,2.39),(1.365,3.39),(1.595,3.39),(1.595,2.77),(3.605,2.77),(3.605,3.39),(3.835,3.39),(3.835,2.39),(2.71,2.39),(2.71,1.44),(3.835,1.44),(3.835,0.675),(3.605,0.675),(3.605,1.06),(1.595,1.06),(1.595,0.675)],
  [(0,-0.3),(0,0.3),(0.245,0.3),(0.245,0.97),(0.475,0.97),(0.475,0.3),(2.485,0.3),(2.485,0.775),(2.715,0.775),(2.715,0.3),(4.725,0.3),(4.725,0.975),(4.955,0.975),(4.955,0.3),(5.6,0.3),(5.6,-0.3)],
  [(0.245,2.615),(0.245,3.62),(0,3.62),(0,4.22),(5.6,4.22),(5.6,3.62),(4.955,3.62),(4.955,2.62),(4.725,2.62),(4.725,3.62),(2.715,3.62),(2.715,3.13),(2.485,3.13),(2.485,3.62),(0.475,3.62),(0.475,2.615)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,5.88,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,5.6,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,6.03,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (2.8,-0.025), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (2.52,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('I', (1.4,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (2.8,3.93), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__inv_4.gds')
