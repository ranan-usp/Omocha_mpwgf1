* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__inv_16 I VDD VNW VSS ZN
XM1 ZN I VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=16
XM2 ZN I VDD VNW pfet_05v0 w=1.22u l=0.5u m=16
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__inv_16')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,19.04,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76,19.47,4.35)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34,18.46,1.16), (0.18,2.36,18.36,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,3.8),(1.12,3.8),(1.12,2.06),(1.74,2.06),(1.74,3.8),(2.24,3.8),(2.24,2.06),(2.86,2.06),(2.86,3.8),(3.36,3.8),(3.36,2.06),(3.98,2.06),(3.98,3.8),(4.48,3.8),(4.48,2.06),(5.1,2.06),(5.1,3.8),(5.6,3.8),(5.6,2.06),(6.22,2.06),(6.22,3.8),(6.72,3.8),(6.72,2.06),(7.34,2.06),(7.34,3.8),(7.84,3.8),(7.84,2.06),(8.46,2.06),(8.46,3.8),(8.96,3.8),(8.96,2.06),(9.58,2.06),(9.58,3.8),(10.08,3.8),(10.08,2.06),(10.7,2.06),(10.7,3.8),(11.2,3.8),(11.2,2.06),(11.82,2.06),(11.82,3.8),(12.32,3.8),(12.32,2.06),(12.94,2.06),(12.94,3.8),(13.44,3.8),(13.44,2.06),(14.06,2.06),(14.06,3.8),(14.56,3.8),(14.56,2.06),(15.18,2.06),(15.18,3.8),(15.68,3.8),(15.68,2.06),(16.3,2.06),(16.3,3.8),(16.8,3.8),(16.8,2.06),(17.42,2.06),(17.42,3.8),(17.92,3.8),(17.92,1.44),(18.02,1.44),(18.02,0.12),(17.42,0.12),(17.42,1.7),(16.9,1.7),(16.9,0.12),(16.3,0.12),(16.3,1.7),(15.78,1.7),(15.78,0.12),(15.18,0.12),(15.18,1.7),(14.66,1.7),(14.66,0.12),(14.06,0.12),(14.06,1.7),(13.54,1.7),(13.54,0.12),(12.94,0.12),(12.94,1.7),(12.42,1.7),(12.42,0.12),(11.82,0.12),(11.82,1.7),(11.3,1.7),(11.3,0.12),(10.7,0.12),(10.7,1.7),(10.18,1.7),(10.18,0.12),(9.58,0.12),(9.58,1.7),(9.06,1.7),(9.06,0.12),(8.46,0.12),(8.46,1.7),(7.94,1.7),(7.94,0.12),(7.34,0.12),(7.34,1.7),(6.82,1.7),(6.82,0.12),(6.22,0.12),(6.22,1.7),(5.7,1.7),(5.7,0.12),(5.1,0.12),(5.1,1.7),(4.58,1.7),(4.58,0.12),(3.98,0.12),(3.98,1.7),(3.46,1.7),(3.46,0.12),(2.86,0.12),(2.86,1.7),(2.34,1.7),(2.34,0.12),(1.74,0.12),(1.74,1.7),(1.22,1.7),(1.22,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,19.24,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,19.24,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 2.49, 0.41, 0.22, 0.22, 7, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 1.37, 0.735, 0.22, 0.22, 8, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.69, 1.77, 0.22, 0.22, 17, 1, 0.47, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 10.085, 1.77, 0.22, 0.22, 17, 1, 0.47, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 10.23, 2.63, 0.22, 0.22, 4, 2, 2.24, 0.47)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 2.39, 3.29, 0.22, 0.22, 7, 1, 2.24, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(0.25,0.735,0.47,0.955), (18.17,0.735,18.39,0.955), (1.37,2.63,1.59,2.85), (3.51,2.63,3.73,2.85), (5.75,2.63,5.97,2.85), (8.085,2.63,8.305,2.85), (0.25,2.74,0.47,2.96), (18.07,2.74,18.29,2.96), (1.37,3.1,1.59,3.32), (3.51,3.1,3.73,3.32), (5.75,3.1,5.97,3.32), (8.085,3.1,8.305,3.32), (0.25,3.21,0.47,3.43), (18.07,3.21,18.29,3.43)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.62,1.765,8.51,2.19), (10.015,1.765,17.92,2.19)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(1.365,0.675),(1.365,1.445),(8.79,1.445),(8.79,2.42),(1.365,2.42),(1.365,3.39),(1.595,3.39),(1.595,3),(3.505,3),(3.505,3.39),(3.735,3.39),(3.735,3),(5.745,3),(5.745,3.39),(5.975,3.39),(5.975,3),(8.08,3),(8.08,3.39),(8.31,3.39),(8.31,3),(10.225,3),(10.225,3.39),(10.455,3.39),(10.455,3),(12.465,3),(12.465,3.39),(12.695,3.39),(12.695,3),(14.705,3),(14.705,3.39),(14.935,3.39),(14.935,3),(16.945,3),(16.945,3.39),(17.175,3.39),(17.175,2.42),(9.69,2.42),(9.69,1.445),(17.275,1.445),(17.275,0.675),(17.045,0.675),(17.045,0.865),(15.035,0.865),(15.035,0.675),(14.805,0.675),(14.805,0.865),(12.795,0.865),(12.795,0.675),(12.565,0.675),(12.565,0.865),(10.555,0.865),(10.555,0.675),(10.325,0.675),(10.325,0.865),(8.315,0.865),(8.315,0.675),(8.085,0.675),(8.085,0.865),(6.075,0.865),(6.075,0.675),(5.845,0.675),(5.845,0.865),(3.835,0.865),(3.835,0.675),(3.605,0.675),(3.605,0.865),(1.625,0.865),(1.625,0.675)],
  [(0,-0.3),(0,0.3),(0.245,0.3),(0.245,1.015),(0.475,1.015),(0.475,0.3),(2.43,0.3),(2.43,0.635),(2.77,0.635),(2.77,0.3),(4.67,0.3),(4.67,0.635),(5.01,0.635),(5.01,0.3),(6.91,0.3),(6.91,0.635),(7.25,0.635),(7.25,0.3),(9.15,0.3),(9.15,0.635),(9.49,0.635),(9.49,0.3),(11.39,0.3),(11.39,0.635),(11.73,0.635),(11.73,0.3),(13.63,0.3),(13.63,0.635),(13.97,0.635),(13.97,0.3),(15.87,0.3),(15.87,0.635),(16.21,0.635),(16.21,0.3),(18.165,0.3),(18.165,1.015),(18.395,1.015),(18.395,0.3),(19.04,0.3),(19.04,-0.3)],
  [(0.245,2.68),(0.245,3.62),(0,3.62),(0,4.22),(19.04,4.22),(19.04,3.62),(18.295,3.62),(18.295,2.68),(18.065,2.68),(18.065,3.62),(16.055,3.62),(16.055,3.23),(15.825,3.23),(15.825,3.62),(13.815,3.62),(13.815,3.23),(13.585,3.23),(13.585,3.62),(11.575,3.62),(11.575,3.23),(11.345,3.23),(11.345,3.62),(9.335,3.62),(9.335,3.23),(9.105,3.23),(9.105,3.62),(7.095,3.62),(7.095,3.23),(6.865,3.23),(6.865,3.62),(4.855,3.62),(4.855,3.23),(4.625,3.23),(4.625,3.62),(2.615,3.62),(2.615,3.23),(2.385,3.23),(2.385,3.62),(0.475,3.62),(0.475,2.68)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,19.32,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,19.04,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,19.47,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (9.24,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (9.24,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('I', (4.76,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (9.24,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__inv_16.gds')
