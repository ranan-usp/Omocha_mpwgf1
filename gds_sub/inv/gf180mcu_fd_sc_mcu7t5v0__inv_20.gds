* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__inv_20 I VDD VNW VSS ZN
XM1 ZN I VSS VSUBS nfet_05v0 w=0.82u l=0.6u m=20
XM2 ZN I VDD VNW pfet_05v0 w=1.22u l=0.5u m=20
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__inv_20')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,23.52,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76,23.95,4.35)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.34,22.94,1.16), (0.18,2.36,22.84,3.58)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,3.8),(1.12,3.8),(1.12,2.06),(1.74,2.06),(1.74,3.8),(2.24,3.8),(2.24,2.06),(2.86,2.06),(2.86,3.8),(3.36,3.8),(3.36,2.06),(3.98,2.06),(3.98,3.8),(4.48,3.8),(4.48,2.06),(5.1,2.06),(5.1,3.8),(5.6,3.8),(5.6,2.06),(6.22,2.06),(6.22,3.8),(6.72,3.8),(6.72,2.06),(7.34,2.06),(7.34,3.8),(7.84,3.8),(7.84,2.06),(8.46,2.06),(8.46,3.8),(8.96,3.8),(8.96,2.06),(9.58,2.06),(9.58,3.8),(10.08,3.8),(10.08,2.06),(10.7,2.06),(10.7,3.8),(11.2,3.8),(11.2,2.06),(11.82,2.06),(11.82,3.8),(12.32,3.8),(12.32,2.06),(12.94,2.06),(12.94,3.8),(13.44,3.8),(13.44,2.06),(14.06,2.06),(14.06,3.8),(14.56,3.8),(14.56,2.06),(15.18,2.06),(15.18,3.8),(15.68,3.8),(15.68,2.06),(16.3,2.06),(16.3,3.8),(16.8,3.8),(16.8,2.06),(17.42,2.06),(17.42,3.8),(17.92,3.8),(17.92,2.06),(18.54,2.06),(18.54,3.8),(19.04,3.8),(19.04,2.06),(19.66,2.06),(19.66,3.8),(20.16,3.8),(20.16,2.06),(20.78,2.06),(20.78,3.8),(21.28,3.8),(21.28,2.06),(21.9,2.06),(21.9,3.8),(22.4,3.8),(22.4,1.44),(22.5,1.44),(22.5,0.12),(21.9,0.12),(21.9,1.7),(21.38,1.7),(21.38,0.12),(20.78,0.12),(20.78,1.7),(20.26,1.7),(20.26,0.12),(19.66,0.12),(19.66,1.7),(19.14,1.7),(19.14,0.12),(18.54,0.12),(18.54,1.7),(18.02,1.7),(18.02,0.12),(17.42,0.12),(17.42,1.7),(16.9,1.7),(16.9,0.12),(16.3,0.12),(16.3,1.7),(15.78,1.7),(15.78,0.12),(15.18,0.12),(15.18,1.7),(14.66,1.7),(14.66,0.12),(14.06,0.12),(14.06,1.7),(13.54,1.7),(13.54,0.12),(12.94,0.12),(12.94,1.7),(12.42,1.7),(12.42,0.12),(11.82,0.12),(11.82,1.7),(11.3,1.7),(11.3,0.12),(10.7,0.12),(10.7,1.7),(10.18,1.7),(10.18,0.12),(9.58,0.12),(9.58,1.7),(9.06,1.7),(9.06,0.12),(8.46,0.12),(8.46,1.7),(7.94,1.7),(7.94,0.12),(7.34,0.12),(7.34,1.7),(6.82,1.7),(6.82,0.12),(6.22,0.12),(6.22,1.7),(5.7,1.7),(5.7,0.12),(5.1,0.12),(5.1,1.7),(4.58,1.7),(4.58,0.12),(3.98,0.12),(3.98,1.7),(3.46,1.7),(3.46,0.12),(2.86,0.12),(2.86,1.7),(2.34,1.7),(2.34,0.12),(1.74,0.12),(1.74,1.7),(1.22,1.7),(1.22,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,23.72,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,23.72,1.76)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 2.49, 0.41, 0.22, 0.22, 9, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 1.37, 0.735, 0.22, 0.22, 10, 1, 2.24, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.69, 1.77, 0.22, 0.22, 16, 1, 0.47, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 15.045, 1.77, 0.22, 0.22, 16, 1, 0.47, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 3.51, 2.625, 0.22, 0.22, 9, 2, 2.24, 0.47)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 2.39, 3.29, 0.22, 0.22, 9, 1, 2.24, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(0.25,0.735,0.47,0.955), (22.65,0.735,22.87,0.955), (1.37,2.625,1.59,2.845), (0.25,2.74,0.47,2.96), (22.55,2.74,22.77,2.96), (1.37,3.095,1.59,3.315), (0.25,3.21,0.47,3.43), (22.55,3.21,22.77,3.43)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.61,1.765,8.02,2.15), (14.985,1.765,22.375,2.15)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(3.605,0.675),(3.605,0.865),(1.65,0.865),(1.65,0.73),(1.31,0.73),(1.31,1.535),(8.415,1.535),(8.415,1.605),(11.03,1.605),(11.03,2.315),(8.395,2.315),(8.395,2.38),(1.365,2.38),(1.365,3.375),(1.595,3.375),(1.595,3.055),(3.505,3.055),(3.505,3.375),(3.735,3.375),(3.735,3.055),(5.745,3.055),(5.745,3.375),(5.975,3.375),(5.975,3.055),(7.985,3.055),(7.985,3.375),(8.215,3.375),(8.215,3.055),(10.225,3.055),(10.225,3.375),(10.455,3.375),(10.455,3.055),(12.465,3.055),(12.465,3.375),(12.695,3.375),(12.695,3.055),(14.705,3.055),(14.705,3.375),(14.935,3.375),(14.935,3.055),(16.945,3.055),(16.945,3.375),(17.175,3.375),(17.175,3.055),(19.185,3.055),(19.185,3.375),(19.415,3.375),(19.415,3.055),(21.425,3.055),(21.425,3.375),(21.655,3.375),(21.655,2.38),(14.665,2.38),(14.665,2.315),(11.93,2.315),(11.93,1.605),(14.77,1.605),(14.77,1.535),(21.755,1.535),(21.755,0.675),(21.525,0.675),(21.525,0.865),(19.515,0.865),(19.515,0.675),(19.285,0.675),(19.285,0.865),(17.275,0.865),(17.275,0.675),(17.045,0.675),(17.045,0.865),(15.035,0.865),(15.035,0.675),(14.805,0.675),(14.805,0.865),(12.795,0.865),(12.795,0.675),(12.565,0.675),(12.565,0.865),(10.555,0.865),(10.555,0.675),(10.325,0.675),(10.325,0.865),(8.315,0.865),(8.315,0.675),(8.085,0.675),(8.085,0.865),(6.075,0.865),(6.075,0.675),(5.845,0.675),(5.845,0.865),(3.835,0.865),(3.835,0.675)],
  [(0,-0.3),(0,0.3),(0.245,0.3),(0.245,1.015),(0.475,1.015),(0.475,0.3),(2.43,0.3),(2.43,0.635),(2.77,0.635),(2.77,0.3),(4.67,0.3),(4.67,0.635),(5.01,0.635),(5.01,0.3),(6.91,0.3),(6.91,0.635),(7.25,0.635),(7.25,0.3),(9.15,0.3),(9.15,0.635),(9.49,0.635),(9.49,0.3),(11.39,0.3),(11.39,0.635),(11.73,0.635),(11.73,0.3),(13.63,0.3),(13.63,0.635),(13.97,0.635),(13.97,0.3),(15.87,0.3),(15.87,0.635),(16.21,0.635),(16.21,0.3),(18.11,0.3),(18.11,0.635),(18.45,0.635),(18.45,0.3),(20.35,0.3),(20.35,0.635),(20.69,0.635),(20.69,0.3),(22.645,0.3),(22.645,1.015),(22.875,1.015),(22.875,0.3),(23.52,0.3),(23.52,-0.3)],
  [(0.245,2.64),(0.245,3.62),(0,3.62),(0,4.22),(23.52,4.22),(23.52,3.62),(22.775,3.62),(22.775,2.64),(22.545,2.64),(22.545,3.62),(20.59,3.62),(20.59,3.285),(20.25,3.285),(20.25,3.62),(18.35,3.62),(18.35,3.285),(18.01,3.285),(18.01,3.62),(16.11,3.62),(16.11,3.285),(15.77,3.285),(15.77,3.62),(13.87,3.62),(13.87,3.285),(13.53,3.285),(13.53,3.62),(11.63,3.62),(11.63,3.285),(11.29,3.285),(11.29,3.62),(9.39,3.62),(9.39,3.285),(9.05,3.285),(9.05,3.62),(7.15,3.62),(7.15,3.285),(6.81,3.285),(6.81,3.62),(4.91,3.62),(4.91,3.285),(4.57,3.285),(4.57,3.62),(2.67,3.62),(2.67,3.285),(2.33,3.285),(2.33,3.62),(0.475,3.62),(0.475,2.64)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,23.8,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,23.52,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,23.95,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (11.76,0.005), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('ZN', (11.48,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('I', (4.2,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (11.76,3.905), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__inv_20.gds')
